# This will set BTS_HW_VERSION depending on the machine
PACKAGE_ARCH = "${MACHINE_ARCH}"
BTS_HW_VERSION_sysmobts-v2 = "-DHW_SYSMOBTS_V2"
