require recipes-fixes/cronie/${PN}_sysmocom.inc
