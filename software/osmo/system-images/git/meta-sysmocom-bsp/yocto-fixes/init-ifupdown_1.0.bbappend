require recipes-bsp/init-ifupdown/${PN}_sysmocom-master.inc
