EXTRA_OECONF += " --enable-static "

