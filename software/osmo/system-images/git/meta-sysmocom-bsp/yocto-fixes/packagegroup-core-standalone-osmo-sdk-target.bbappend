SDK-OSMO_append = "femtobts-api-dev gpsd-dev"
SDK-OSMO_append_sysmobts2100 = " lc15-firmware-dev"

PRINC = "3"
