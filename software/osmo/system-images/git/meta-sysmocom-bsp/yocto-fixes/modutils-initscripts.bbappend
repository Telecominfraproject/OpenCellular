require recipes-fixes/modutils/${PN}_sysmocom.inc
