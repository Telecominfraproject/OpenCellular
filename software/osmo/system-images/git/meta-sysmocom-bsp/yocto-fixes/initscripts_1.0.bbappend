require recipes-fixes/initscripts/${PN}_master.inc
