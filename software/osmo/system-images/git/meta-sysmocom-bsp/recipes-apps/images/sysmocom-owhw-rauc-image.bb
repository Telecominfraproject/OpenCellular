require sysmocom-owhw-image.bb
require sysmocom-rauc-slot.inc
