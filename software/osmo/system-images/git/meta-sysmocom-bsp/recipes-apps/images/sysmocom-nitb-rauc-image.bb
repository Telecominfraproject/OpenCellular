require sysmocom-nitb-image.bb
require sysmocom-rauc-slot.inc
