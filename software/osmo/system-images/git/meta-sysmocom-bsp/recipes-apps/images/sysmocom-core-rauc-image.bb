require sysmocom-core-image.bb
require sysmocom-rauc-slot.inc
