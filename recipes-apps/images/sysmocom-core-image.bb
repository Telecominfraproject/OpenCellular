require sysmocom-image.inc
