require sysmocom-image.inc

IMAGE_INSTALL_append = " task-sysmocom "
