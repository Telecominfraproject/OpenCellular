require recipes-sysmobts/uboot/${PN}_sysmocom.inc
