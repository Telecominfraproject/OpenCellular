require recipes-fixes/${PN}/${PN}_angstrom.inc
