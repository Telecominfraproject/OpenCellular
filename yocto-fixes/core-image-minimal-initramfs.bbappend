# add e2fsprogs for resize2fs need for bts installation
IMAGE_INSTALL_append = " e2fsprogs "
