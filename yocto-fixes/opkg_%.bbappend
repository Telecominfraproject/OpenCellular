require recipes-fixes/${PN}/${PN}_sysmocom.inc
