require recipes-core/initrdscripts/${PN}_sysmocom.inc
