require recipes-bsp/${PN}/${PN}_sysmocom.inc
